File: PCB - CPU V1/Interrupt.kicad_sch (KiCad schematic)
At the start: 6 parts, among them U14 ATF22V10C, U15 74HCT573

Commit message: CPU Card
Parts:
- gave numbers to parts that had none: 4
