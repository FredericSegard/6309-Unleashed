File: PCB - CPU V1/Acia.kicad_sch (KiCad schematic)
At the start: 20 parts

Commit message: CPU Card
Parts:
- gave numbers to parts that had none: 8
